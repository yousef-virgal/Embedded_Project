<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Team16 final project.ewp</path>
    </project>
    <batchBuild />
</workspace>
